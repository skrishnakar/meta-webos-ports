# Add support for hardware accelerated audio/video decoding through the Android HAL
SRC_URI += "file://0001-Adding-mirsink-and-Android-media-over-hybris-support.patch"
