# Building docbook-utils-native fails when the following package isn't build and populated
# within sysroot
DEPENDS += "docbook-sgml-dtd-4.1-native"
